** sch_path: cace/templates/ota_tb_slew.sch
**.subckt ota_tb_slew
XM1B net2 CM2 GND GND sky130_fd_pr__nfet_01v8 L=1.5 W=2.75 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2B CM2 VINP net2 net2 sky130_fd_pr__nfet_01v8 L=2.0 W=4.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1A net1 CM1 GND GND sky130_fd_pr__nfet_01v8 L=1.5 W=2.75 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2A CM1 VINN net1 net1 sky130_fd_pr__nfet_01v8 L=2.0 W=4.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3B net3 net5 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=1.0 W=4.53 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM3A net4 net5 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=1.0 W=4.53 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM4B VOUT net3 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=1.0 W=4.53 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM4A net6 net4 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=1.0 W=4.53 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
C1 VOUT GND CACE{cl} m=1
XM5A net6 net6 GND GND sky130_fd_pr__nfet_01v8 L=3.45 W=0.45 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM5B VOUT net6 GND GND sky130_fd_pr__nfet_01v8 L=3.45 W=0.45 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XMinA net4 VINN net2 net2 sky130_fd_pr__nfet_01v8 L=2.0 W=4.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XMinB net3 VINP net1 net1 sky130_fd_pr__nfet_01v8 L=2.0 W=4.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x2 net5 net4 VCC GND VCC VSS passgate_nlvt W_N=0.5 L_N=4 W_P=3 L_P=4 m=1
x1 net5 net3 VCC GND VCC VSS passgate_nlvt W_N=0.5 L_N=4 W_P=3 L_P=4 m=1
E1 VINP net8 net7 GND 0.5
E2 VINN net8 net7 GND -0.5
Vdm net7 GND 0
Vcm net8 GND dc 1.2 ac 1
vin VCC GND CACE{vcc}
XCM1 CM1 net9 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3.0 W=1.88 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XCM2 net9 net9 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3.0 W=1.88 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
I0 net9 GND CACE{IBIAS}
I1 net10 GND CACE{IBIAS}
C2 VCC net9 10p m=1
XCM3 CM2 net10 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3.0 W=1.88 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XCM4 net10 net10 VCC VCC sky130_fd_pr__pfet_01v8_lvt L=3.0 W=1.88 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
C3 VCC net10 10p m=1
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
    * run ac simulation
    ac dec 20 1 1e12

    * measure parameters
    let cmrr_val = db(v(vout)) 180/pi*ph(v(vout))

    wrdata CACE{simpath}/CACE{filename}_CACE{N}.data cmrr_val

.endc


**** end user architecture code
**.ends

* expanding   symbol:  sky130_tests/passgate_nlvt.sym # of pins=4
** sym_path: sky130_tests/passgate_nlvt.sym
** sch_path: sky130_tests/passgate_nlvt.sch
.subckt passgate_nlvt Z A GP GN VCCBPIN VSSBPIN  W_N=1 L_N=0.35 W_P=1 L_P=0.35
*.iopin A
*.iopin Z
*.ipin GP
*.ipin GN
XM1 net1 GN net2 VSS sky130_fd_pr__nfet_01v8_lvt L=L_N W=W_N nf=1 ad=ad as=as pd=pd ps=ps nrd=0 nrs=0 sa=0 sb=0 sd=0 mult=1 m=1
XM2 A GP Z VCC sky130_fd_pr__pfet_01v8 W=W_P L=L_P ad=ad pd=pd as=as ps=ps nrd=0 nrs=0 sa=0 sb=0 sd=0 nf=1 mult=1
.ends

.GLOBAL GND
.GLOBAL VCC
.end
