v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {@name} 40 50 0 0 0.4 0.4 {}
C {devices/ipin.sym} -30 60 0 0 {name=p4 lab=IBIAS}
C {devices/ipin.sym} -30 110 0 0 {name=p1 lab=VIN}
C {devices/opin.sym} 90 110 0 0 {name=p2 lab=VOUT}
C {devices/iopin.sym} 30 160 1 0 {name=p3 lab=GND}
C {devices/iopin.sym} 0 -60 3 0 {name=p5 lab=VCC}
C {/foss/designs/fvf-chipathon-2024/xschem/fvf.sym} 30 110 0 0 {name=X1}
C {/foss/designs/fvf-chipathon-2024/xschem/cmirror.sym} 0 0 0 0 {name=X2}
