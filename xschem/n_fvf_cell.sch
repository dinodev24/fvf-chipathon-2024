v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/fvf-chipathon-2024/xschem/cmirror.sym} 0 0 0 0 {}
C {/foss/designs/fvf-chipathon-2024/xschem/fvf.sym} 30 110 0 0 {name=X1}
C {devices/vdd.sym} 0 -60 0 0 {name=l1 lab=VCC}
C {devices/ipin.sym} -30 60 0 0 {name=p4 lab=IBIAS}
C {devices/gnd.sym} 30 160 0 0 {name=l2 lab=GND}
C {devices/ipin.sym} -30 110 0 0 {name=p1 lab=VIN}
C {devices/opin.sym} 90 110 0 0 {name=p2 lab=VOUT}
